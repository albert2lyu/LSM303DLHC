# Keil uVision project Template.uvprojx, settings and files
target Template (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xe,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\IIC;..\HARDWARE\LSM303DLHC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_i2c.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LSM303DLHC/: LSM303.c
    ../HARDWARE/IIC/: i2c.c
software components: CMSIS:CORE 4.3.0
